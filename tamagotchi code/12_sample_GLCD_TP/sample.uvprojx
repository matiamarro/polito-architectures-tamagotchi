# Keil uVision project sample.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: SIMULATOR
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./: sample.c
  group lib_SoC_board
    ./: core_cm3.c system_LPC17xx.c
  group timer
    ./timer/: IRQ_timer.c lib_timer.c timer.h
  group GLCD
    ./GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h HzLib.c HzLib.h
  group led
    ../../../../landtiger/template/08_sample_JOYSTICK/08_sample_JOYSTICK/led/: funct_led.c led.h lib_led.c
  group joystick
    ../../../../landtiger/template/08_sample_JOYSTICK/08_sample_JOYSTICK/joystick/: funct_joystick.c joystick.h lib_joystick.c
  group RIT
    ./RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group TouchPanel
    ./TouchPanel/: TouchPanel.c TouchPanel.h
  group aliens
    ./aliens/: alien1.c alien1.h alien1_image.c
  group adc
    ./adc/: IRQ_adc.c lib_adc.c adc.h
  group music
    ./music/: music.c music.h
software components: CMSIS:CORE 5.4.0
